# IAR project STM8S105CORE.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105S4 STM8S105S4
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S105
  ICCSTM8.CCIncludePath2: STM8S_StdPeriph_Driver\inc; Config
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: STM8S105CORE.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group Application
    Application/: main.c
  group Config
    Config/: stm8s_conf.h
  group STM8S_StdPeriph_Driver
    STM8S_StdPeriph_Driver/src/: stm8s_adc1.c stm8s_awu.c stm8s_beep.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_tim3.c stm8s_tim4.c stm8s_uart2.c stm8s_wwdg.c
